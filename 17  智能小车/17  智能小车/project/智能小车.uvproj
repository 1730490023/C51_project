# Keil uVision project 智能小车.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 智能小车 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\source
  asm include: ..\source
  link misc: REMOVEUNUSED
  group 源组 1
    ../source/: lcd1602.c display.c main.c moto.c public.c speed.c Ultra.c
