# Keil uVision project xunji.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: xunji +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group 源组 1
    ../source/: hwdg.c moto.c main.c public.c
