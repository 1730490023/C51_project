# Keil uVision project oled.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: oled +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib
  group 源组 1
    ./: oled.c
    ./lib/: OLED_12864.c IIC.c codetab.c
